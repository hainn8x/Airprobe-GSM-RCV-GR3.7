<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>gr_uchar_to_float_1</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>gr_uchar_to_float_0</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>gr_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-127</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>gr_add_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-127</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.008</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.008</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>gr_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>gr_deinterleave_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>/gsm/cfile.out</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>file</key><value>/gsm/capture.cfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>gr_float_to_complex_0</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_const_vxx_1</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_add_const_vxx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_uchar_to_float_1</source_block_id><sink_block_id>gr_add_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_uchar_to_float_0</source_block_id><sink_block_id>gr_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_uchar_to_float_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_deinterleave_0</source_block_id><sink_block_id>gr_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
